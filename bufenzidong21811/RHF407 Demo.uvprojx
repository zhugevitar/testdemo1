# Keil uVision project RHF407 Demo.uvprojx, settings and files
target RHF407 Demo (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RHF407 Demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, __FPU_PRESENT = 1, __FPU_USED = 1, ARM_MATH_CM4
  c include: .\App\inc;.\Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./App/src/: app_main.c stm32f4xx_it.c app_protocol_can.c app_robot_control.c
  group Driver
    ./Driver/src/: drv_button.c drv_can.c drv_led.c drv_uart.c drv_timer.c drv_delay.c iwdg.c
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_iwdg.c
  group Startup
    ./Startup/: startup_stm32f4xx.s system_stm32f4xx.c
